# Keil uVision project STM32F030_I2C_DMA.uvprojx, settings and files
target STM32F030_I2C_DMA (6140000::V6.14::ARMCLANG)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F030_I2C_DMA
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F030
  c include: .\User;.\STM32F0xx_StdPeriph_Driver\inc;.\CMSIS\Include;.\CMSIS\Device\ST\STM32F0xx;.\CMSIS\Device\ST\STM32F0xx\Include
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ./CMSIS/Include/: core_cm0.h
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Startup
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group Std_Lib
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_dma.c stm32f0xx_i2c.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_rcc.c stm32f0xx_gpio.c
  group User
    ./User/: main.c
